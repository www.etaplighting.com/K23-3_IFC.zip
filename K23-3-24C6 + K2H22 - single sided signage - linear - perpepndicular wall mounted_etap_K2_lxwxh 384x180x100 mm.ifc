Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-10-12T04:16:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - IFC Model Exchange with Archicad 24.0.0.4000
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 12 04:16:31 2023 * Host: DESKTOP-9UDG1IS * Database: C:\Users\LINIA_3\AppData\Local\Temp\58e99fc5-b40c-4897-842e-5db4fa8b3c52\34e29449-bb95-4631-b17e-cc003386ebad\ifc * Database version: 5507 * Database creation date: Thu Oct 12 04:16:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 12 04:16:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 12 04:16:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, bottom
LongName: bottom; Elevation: -4000 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Pset_AirSideSystemInformation - Name: bottom
Pset_ProductRequirements - Name: bottom; Category: Levels
Constraints - Elevation: -4000 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: bottom; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcDistributionPort, Port_408529
Description: Flow; FlowDirection: SOURCEANDSINK

# IfcFlowTerminal: RSen_68_LF_FB_emergency lighting fixture_K2_etap:K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm, RSen_68_LF_FB_emergency lighting fixture_K2_etap:K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm:408529
In: bottom
Type - PredefinedType: DIRECTIONSOURCE; Classification: 63.10.30 (Uniformat); Material: RSen_rgb_236 236 231_T00 RAL9003_etap (2), RSen_x_rgb 255 128 128 T80 red_gen, <Unnamed> (2)
Type - Constraints - Default Elevation: 2000 mm
Type - Construction - TB_V_accessory_01: K2H22; TB_V_accessory_02: N/A; TB_V_accessory_03: N/A; TB_V_accessory_04: N/A; TB_V_component_01_description: lighting lixture; TB_V_component_01_diameter: 0 mm; TB_V_component_01_fillet_from.plane.radius_01: 0 mm; TB_V_component_01_fillet_from.plane.radius_02: 0 mm; TB_V_component_01_fillet_in.plane.radius: 0 mm; TB_V_component_01_height: 100 mm; TB_V_component_01_length: 384 mm; TB_V_component_01_plane: 2; TB_V_component_01_width: 180 mm; TB_V_component_01_X-coordinate: 0 mm; TB_V_component_01_Y-coordinate: 0 mm; TB_V_component_01_Z-coordinate: 0 mm; TB_V_component_02_description: -; TB_V_component_02_diameter: 0 mm; TB_V_component_02_fillet_from.plane.radius_01: 0 mm; TB_V_component_02_fillet_from.plane.radius_02: 0 mm; TB_V_component_02_fillet_in.plane.radius: 0 mm; TB_V_component_02_height: 0 mm; TB_V_component_02_length: 0 mm; TB_V_component_02_plane: 1; TB_V_component_02_width: 0 mm; TB_V_component_02_X-coordinate: 0 mm; TB_V_component_02_Y-coordinate: 0 mm; TB_V_component_02_Z-coordinate: 0 mm; TB_V_component_03_description: -; TB_V_component_03_diameter: 0 mm; TB_V_component_03_fillet_from.plane.radius_01: 0 mm; TB_V_component_03_fillet_from.plane.radius_02: 0 mm; TB_V_component_03_fillet_in.plane.radius: 0 mm; TB_V_component_03_height: 0 mm; TB_V_component_03_length: 0 mm; TB_V_component_03_plane: 1; TB_V_component_03_width: 0 mm; TB_V_component_03_X-coordinate: 0 mm; TB_V_component_03_Y-coordinate: 0 mm; TB_V_component_03_Z-coordinate: 0 mm; TB_V_configuration_ceiling.mounted: no; TB_V_configuration_wall.mounted: no; TB_V_logo: RSen_00_GM_FB_logo - SH_etap: standard; TB_V_placement_flush.mounted: no; TB_V_placement_flush.mounted_depth: 0 mm; TB_V_placement_parallel.to.wall: no; TB_V_placement_perpendicular.to.wall: yes; TB_V_placement_surface.mounted: no; TB_V_placement_suspended.horizontally: no; TB_V_placement_suspended.vertically: no; TB_V_sog_plane: 1; TB_V_sog_rotation: 0 deg; TB_V_sog_X-coordinate: -12.6 mm; TB_V_sog_Y-coordinate: 0 mm; TB_V_sog_Z-coordinate: 0 mm; TB_V_suspension: no; TB_V_suspension_baseplate.height: 0 mm; TB_V_suspension_baseplate.length: 0 mm; TB_V_suspension_baseplate.width: 0 mm; TB_V_suspension_diameter: 2 mm; TB_V_suspension_offset: 0 mm; TB_V_suspension_recess.depth: 0 mm; TB_V_suspension_type: none_gen; TB_V_suspension_X-coordinate: 0 mm; TB_V_suspension_Y-coordinate: 0 mm; TBQen_C_SOg_LF_2D: none; TBQen_C_SOg_LF_3D: K2 - single + K2H22
Type - Dimensions - RSen_C_diameter: 0 mm; RSen_C_height: 100 mm; RSen_C_length: 384 mm; RSen_C_width: 180 mm
Type - Electrical - RSen_E_c01_apparent_power: 3 W; RSen_E_c01_consumer_star_switched: no; RSen_E_c01_consumer_triangle_switched: no; RSen_E_c01_current: 0 A; RSen_E_c01_division_engine: no; RSen_E_c01_number_of_poles: 1; RSen_E_c01_voltage: 230 V; TB_V_power_apparent: 0 W; TBQen_E_apparent_load: 3 W; TBQen_E_c01_power: 3 W; TBQen_E_c01_power_factor: 1; TBQen_E_c01_utility: no; TBQen_E_number_of_lamps: 1; TBQen_E_wattage_ballast: 5 W; TBQen_E_wattage_per_lamp: 0 W
Type - Graphics - TB_V_clearance.zone_back: 0 mm; TB_V_clearance.zone_bottom: 0 mm; TB_V_clearance.zone_front: 0 mm; TB_V_clearance.zone_left: 0 mm; TB_V_clearance.zone_right: 0 mm; TB_V_clearance.zone_top: 0 mm
Type - Identity Data - Assembly Code: 63.10.30; Description: Emergency luminaire for escape route lighting; Manufacturer: gen; Model: K2; RSen_C_code_article: K23/3-24C6; RSen_C_code_ETIM: Plafond-/wandarmatuur; RSen_C_code_ETIM_URL: http://prod.etim-international.com/Class/Details?classId=EC002892&classVersion=2; RSen_C_code_gtin: -; RSen_C_code_product_class: -; RSen_C_content_creator: © ThorbiQ; RSen_C_content_date_changed: 00/00/0000; RSen_C_content_date_issue: 00/00/0000; RSen_C_content_provider: gen; RSen_C_content_version: 1.0.0; RSen_C_description: Emergency luminaire for escape route lighting; RSen_C_model: K2; RSen_C_revit_version: 2018; RSen_C_type: emergency lighting fixture; RSen_C_type_comments: Central system; TB_I_basekeynote: 63.10.30; TBQen_C_accessory: K2H22; TBQen_C_IFC_version: 2x3; TBQen_C_license: Creative Commons Attribution NoDerivs (CC-ND); TBQen_C_license_info: https://tldrlegal.com/license/creative-commons-attribution-noderivs-(cc-nd)#summary; Type Name: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm; URL: -
Type - Materials and Finishes - RSen_C_material: RSen_rgb_236 236 231_T00 RAL9003_etap; TB_V_clearance.zone_material: RSen_x_rgb 255 128 128 T80 red_gen; TB_V_component_01_material: RSen_rgb_236 236 231_T00 RAL9003_etap
Type - Model Properties - TB_I_autonomy: -; TB_I_battery.type: -; TB_I_dimmable: No; TB_I_dimmer: no; TB_I_function: Single sided signage; TB_I_ip: 0; TB_I_lamp.type: LED; TB_I_light.distribution: -; TB_I_light.sensor: no; TB_I_module: -; TB_I_mounting: perpepndicular wall mounted; TB_I_operation: Centraal systeem; TB_I_optics: -; TB_I_permanent: -; TB_I_self.test: -; TB_I_shape: linear; TB_I_suspension_max: 0 mm; TB_I_suspension_min: 0 mm
Type - Other - Category: Lighting Fixtures; Family Name: RSen_68_LF_FB_emergency lighting fixture_K2_etap; RSen_E_c01_description: c01_electrical connector; TB_V_e_c01_plane: 1; TB_V_e_c01_X-coordinate: 0 mm; TB_V_e_c01_Y-coordinate: 0 mm; TB_V_e_c01_Z-coordinate: 0 mm; TBQen_E_c01_system_type: Power - Unbalanced; TBQen_E_c01_yes_no: yes
Type - Photometrics - Color Filter: 16777215; Dimming Lamp Color Temperature Shift: <None>; Efficacy: 148.542 s3*lm/kg/m2; Illuminance: 11.8206 lx; Initial Color: 0; Initial Color Temperature: 5000 K; Initial Intensity: 0; Light Loss Factor: 0; Light Source Definition (family): Point+Photometric Web; Luminous Flux: 130 lm; Luminous Intensity: 109.817 cd; Photometric Web File: C:\ProgramData\Autodesk\ApplicationPlugins\Witas RME_BE_NL Localiser.bundle\IES\K23_3-24C6_LTRevAB.ies; TB_V_field_spot_slope.angle: 0 deg; TB_V_light.source_diameter: 384 mm; TB_V_light.source_length: 384 mm; TB_V_light.source_plane: 2; TB_V_light.source_type: standard_gen; TB_V_light.source_width: 180 mm; TB_V_radius_spot_slope.angle: 90 deg; TB_V_shape_light.source_visible.in.rendering: yes; TB_V_slope.angle: 90 deg; TB_V_symbol.power.balanced_light.source_dimension: 0 mm; Tilt Angle: 90 deg; Total Light Loss Factor: 1; Wattage: 9.2903 W
Type - Pset_DistributionFlowElementCommon - Reference: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: gen
Type - Pset_ProductRequirements - Category: Lighting Fixtures
Type - Pset_QuantityTakeOff - Reference: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm
Material: RSen_rgb_236 236 231_T00 RAL9003_etap, Glass
Pset_DistributionFlowElementCommon - sets with these values: 2
Constraints - Elevation from Level: 0 mm; Host: Reference Plane : v_rightleft
Construction - TB_V_suspension_height: 0 mm; TBQen_C_accessory_01_description: N/A; TBQen_C_accessory_01_index: 0; TBQen_C_accessory_02_description: N/A; TBQen_C_accessory_02_index: 0; TBQen_C_accessory_03_description: N/A; TBQen_C_accessory_03_index: 0; TBQen_C_accessory_04_description: N/A; TBQen_C_accessory_04_index: 0; TBQen_C_alignment: Center; TBQen_C_alignment_index: 0; TBQen_C_GOg: no; TBQen_C_SOg: yes
Dimensions - Area: 2.13502 m2; Volume: 0.0967715 m3
Electrical - RSen_E_c01_load_class: Lighting
Electrical - Circuiting - Electrical Data: c01_electrical connector 230 V/1-3 VA
Electrical - Lighting - Calculate Coefficient of Utilization: yes
Electrical - Loads - TBQen_E_simultaneity_factor: 1
Graphics - TB_V_annotation_position_in.x.direction: 0; TB_V_annotation_position_in.y.direction: 0; TB_V_annotation_X-coordinate: 0 mm; TB_V_annotation_Y-coordinate: 0 mm; TB_V_pictogram_reverse.direction: no; TB_V_pictogram_type: RSen_68_LF_FB_pictogram ann - SH_etap_K2 picto: none_gen; TBQen_C_clearance_zone: no; TBQen_C_logo: no
Identity Data - Mark: 1001
Other - Family: RSen_68_LF_FB_emergency lighting fixture_K2_etap: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm; Family and Type: RSen_68_LF_FB_emergency lighting fixture_K2_etap: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm; Type: RSen_68_LF_FB_emergency lighting fixture_K2_etap: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm; Type Id: RSen_68_LF_FB_emergency lighting fixture_K2_etap: K23-3-24C6 + K2H22 - single sided signage - linear - perpepndicular wall mounted_etap_K2_lxwxh 384x180x100 mm
Phasing - Phase Created: New Construction
